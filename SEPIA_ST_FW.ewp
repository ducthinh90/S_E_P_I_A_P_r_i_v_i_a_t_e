# IAR project SEPIA_ST_FW.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207IG ST STM32F207IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F2XX
  ICCARM.CCIncludePath2: App\inc; CMSIS\Include; Flash\inc; FW_Update\inc; Sonar_Navigate\inc; STM32F2xx_StdPeriph_Driver\inc; Utils\inc; CMSIS\Device\ST\STM32F2xx\Include; Icon
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SEPIA_ST_FW.hex
  ILINK.IlinkOutputFile: SEPIA_ST_FW.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/inc
    App/inc/: alldefs.h backgrounds.h basic_io.h flashmem.h gpio.h handleButtons.h stm32100b_eval.h stm322xg_eval_lcd.h stm32_eval.h stm32_eval_spi_flash.h stm32f2xx_conf.h stm32f2xx_it.h stopWatch.h text.h
  group App/src
    App/src/: FinalArray.c flashmem.c gpio.c handleButtons.c IconSEPIA.c lcd.c main.c ShapeSEPIA.c stm322xg_eval_lcd.c stm32f2xx_it.c stopWatch.c
  group CMSIS
    CMSIS/: chconf.h halconf.h mcuconf.h
  group CMSIS/Device
    CMSIS/Device/: chconf.h halconf.h mcuconf.h
  group CMSIS/Device/ST
    CMSIS/Device/ST/: chconf.h halconf.h mcuconf.h
  group CMSIS/Device/ST/STM32F2xx/Include
    CMSIS/Device/ST/STM32F2xx/Include/: chconf.h halconf.h mcuconf.h stm32f2xx.h system_stm32f2xx.h
  group CMSIS/Device/ST/STM32F2xx/Source
    CMSIS/Device/ST/STM32F2xx/Source/: system_stm32f2xx.c
  group CMSIS/Device/ST/STM32F2xx/Source/Templates/iar
    CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
  group CMSIS/Include
    CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group Flash/inc
    Flash/inc/: flashDrv.h flashDrvDefs.h flashTest.h
  group Flash/src
    Flash/src/: flashDrv.c flashTest.c
  group Font
    Font/: myriad_bold_22_Antialiasing.c myriad_bold_57_Antialiasing.c
  group FW_Update/inc
    FW_Update/inc/: fwUpdate.h
  group FW_Update/src
    FW_Update/src/: fwUpdate.c fwUpdateTest.c
  group Sonar_Navigate/inc
    Sonar_Navigate/inc/: dspFW_hexSections.h dspFW_hexSections_v4.h errors.h hpiMsg.h sonarCmd.h sonarCtrl.h sonarTest.h sonarTextDisplay.h sysCtrl.h
  group Sonar_Navigate/src
    Sonar_Navigate/src/: hpiMsg.c sonarCtrl.c sonarTest.c sysCtrl.c
  group STM32F2xx_StdPeriph_Driver/inc
    STM32F2xx_StdPeriph_Driver/inc/: chcore.h chtypes.h misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
  group STM32F2xx_StdPeriph_Driver/src
    STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c
  group Utils/inc
    Utils/inc/: fwDefs.h sysUtils.h textUtils.h typedefs.h
  group Utils/src
    Utils/src/: sysUtils.c textUtils.c
